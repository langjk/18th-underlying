# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\stm32f10x-FWlib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\COER;..\WS\OLED;..\WS\KEY;..\WS\LED;..\WS\TIMER;..\WS\CONTROL;..\WS\MPU6050\eMPL;..\WS\MPU6050;..\WS\MOTOR;..\WS\ENCODER;..\WS\PWM;..\WS\TIMER;..\WS\ADC;..\TJSC_UI;..\Data;..\WS\FLASH;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../COER/: startup_stm32f10x_md.s
    ./: init.c isr.c main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../COER/: core_cm3.c
  group FWLIB
    ../stm32f10x-FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group WS
    ../WS/timer/: timer.c
    ../WS/KEY/: key.c
    ../WS/LED/: led.c
    ../WS/MPU6050/: mpu6050.c mpuiic.c
    ../WS/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../WS/MOTOR/: motor.c
    ../WS/ENCODER/: encoder.c
    ../WS/PWM/: pwm.c
    ../WS/ADC/: adc.c
    ../WS/OLED/: oled.c
    ../WS/FLASH/: flash.c
  group Data
    ../Data/: data_input.c data_output.c data_process.c
  group TJSC_UI
    ../TJSC_UI/: TJSC_Display.c setpara.c TJSC_UI.c
